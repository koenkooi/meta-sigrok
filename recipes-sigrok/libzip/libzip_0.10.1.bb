DESCRIPTION = "C library for reading, creating, and modifying zip archives"
HOMEPAGE = "http://www.nih.at/libzip/"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=22e77599d7f1f06ea27391502c3d3b2a"

inherit autotools

SRC_URI = "http://www.nih.at/libzip/libzip-0.10.1.tar.bz2"
SRC_URI[md5sum] = "d3e933ae049204badccf605f20aaecde"
SRC_URI[sha256sum] = "5b1eaf60968cb22df49d73bcaa759961fb27451917ac76b275374c2ed260ce92"



